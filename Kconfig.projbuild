## Kconfig.projbuild
```kconfig
menu "Component drv_stream Configuration"

    config DRV_STREAM_USE
        bool "Use drv_stream component"
        default y
        
endmenu
```
